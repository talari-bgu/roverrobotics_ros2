Commit message: Update imu.urdf

File: src/roverrobotics_description/urdf/accessories/imu.urdf (robot description, URDF)
Before this commit: robot imu, 1 links, 1 joints
Joints:
- joint imu_to_payload: origin xyz=0 0 0 rpy=0 0 0 -> xyz=-0.195 0 0.100 rpy=0 0 1.57
